python do_hello() {
    bb.plain("Olá Mundo")
}