VAR = "10"