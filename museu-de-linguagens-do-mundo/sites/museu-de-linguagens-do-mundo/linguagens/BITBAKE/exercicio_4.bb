do_compile() { }