PACKAGES = "${PN} ${PN}-dev"