VAR = "${@10 + 5}"