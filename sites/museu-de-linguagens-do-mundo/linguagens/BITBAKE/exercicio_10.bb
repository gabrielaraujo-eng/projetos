addtask hello after do_build