inherit autotools